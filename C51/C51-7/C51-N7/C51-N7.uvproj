# Keil uVision project C51-N7.uvproj, settings and files
target C51-N7 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: C51-N7 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
